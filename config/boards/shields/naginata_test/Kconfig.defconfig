## config/boards/shields/naginata_test/Kconfig.defconfig
```kconfig
if SHIELD_NAGINATA_TEST

config ZMK_KEYBOARD_NAME
    default "Naginata Test"

config NAGINATA
    default y

endif
```
